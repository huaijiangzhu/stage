Commit message: add pendulum task for debugging

File: src/stage/envs/urdf/onelink.urdf (robot description, URDF)
Before this commit: robot TwoJointRobot, 3 links, 2 joints
Links:
- removed link link_2
Joints:
- removed joint joint_2
